# Keil uVision project Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c delay.c delay.h nixie_tube.c nixie_tube.h LCD1602.c LCD1602.h matrix.c matrix.h timer.c timer.h uart.c uart.h dianzhen.c dianzhen.h beep.c beep.h key.c key.h at24c02.c at24c02.h pwm.c pwm.h remote.c remote.h intrrupt.c intrrupt.h demo.c demo.h
